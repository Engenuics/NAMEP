# IAR project abbcn-SD3-SDK4-efwm-01.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422-QFAA NordicSemi nRF51422-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\bsp; ..\application; ..\nordic_sdk4_2_2; ..\nordic_sdk4_2_2\Include; ..\nordic_sdk4_2_2\Include\ant; ..\nordic_sdk4_2_2\Include\app_common; ..\nordic_sdk4_2_2\Source; ..\nordic_sdk4_2_2\Source\app_common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\bsp; ..\mpg_application; ..\nordic_sdk4_2_2; ..\nordic_sdk4_2_2\Include; ..\nordic_sdk4_2_2\Include\ant; ..\nordic_sdk4_2_2\Include\app_common; ..\nordic_sdk4_2_2\Source; ..\nordic_sdk4_2_2\Source\app_common
  OBJCOPY.OOCOutputFile: abbcn-SD3-SDK4-efwm-01.hex
  ILINK.IlinkOutputFile: mpg51-SD3-SDK4-efwm-01.out
  ILINK.IlinkIcfFile: ..\nordic_sdk4_2_2\Source\nRF51422_QFAA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group _BSP/Include
    ../bsp/: abbcn-ehdw-01.h configuration.h i2c_master.h interrupts.h leds_abbcn.h utilities.h
  group _BSP/Source
    ../bsp/: abbcn-ehdw-01.c i2c_master.c interrupts.c leds_abbcn.c utilities.c
  group Application/Include
    ../application/: accelerometer_lis2dh.h lcd_bitmaps.h main.h pov.h typedefs.h
  group Application/Source
    ../application/: accelerometer_lis2dh.c lcd_bitmaps.c main.c pov.c
  group SDK4_2_2/Source
    ../nordic_sdk4_2_2/Source/: iar_startup_nrf51.s nRF51422_QFAA.icf twi_hw_master.c
