<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>_BSP</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\bsp\abbcn-ehdw-01.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\configuration.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\i2c_master.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\interrupts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\leds_abbcn.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\utilities.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\bsp\abbcn-ehdw-01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\i2c_master.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\interrupts.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\leds_abbcn.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\bsp\utilities.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Application</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\..\application\accelerometer_lis2dh.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\lcd_bitmaps.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\pov.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\typedefs.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\application\accelerometer_lis2dh.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\lcd_bitmaps.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\application\pov.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>SDK4_2_2</name>
    <group>
      <name>Include</name>
      <group>
        <name>ant</name>
      </group>
      <group>
        <name>app_common</name>
      </group>
    </group>
    <group>
      <name>Source</name>
      <group>
        <name>app_common</name>
      </group>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk4_2_2\Source\iar_startup_nrf51.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk4_2_2\Source\nRF51422_QFAA.icf</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\nordic_sdk4_2_2\Source\twi_hw_master.c</name>
      </file>
    </group>
  </group>
</project>


